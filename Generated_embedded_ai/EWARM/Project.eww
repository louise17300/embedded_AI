<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Generated_embedded_ai.ewp</path>
  </project>
  <batchBuild />
</workspace>
